SUMMARY = "This module encapsulates the access for the serial port"
HOMEPAGE = "https://pypi.org/project/pyserial/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/BSD;md5=3775480a712fc46a69647678acb234cb"

SRC_URI[md5sum] = "b6b182ebaf20199e9788214cae349df4"
SRC_URI[sha256sum] = "c4451db6ba391ca6ca299fb3ec7bae67a5c55dde170964c7a14ceefec02f2cf0"
 
PYPI_PACKAGE = "pyserial"

inherit setuptools3 pypi


